# Keil uVision project C8T6.uvprojx, settings and files
target EOBD (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EOBD +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\Lib\STM32F10x_StdPeriph_Driver\inc;..\Lib\CMSIS\CM3\CoreSupport;..\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\User;..\SYSTEM\DELAY;..\SYSTEM\sys;..\HARDWARE\CAN;..\SYSTEM\usart;..\HARDWARE\CRC;..\HARDWARE\USART2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: stm32f10x_it.c main.c
  group Lib
    ../Lib/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c misc.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_tim.c
  group CMSIS
    ../Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group HARDWARE
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/CRC/: crc.c
    ../HARDWARE/USART2/: usart2.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
